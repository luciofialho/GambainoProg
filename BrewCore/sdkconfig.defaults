## BrewCore/sdkconfig.defaults
```kconfig
CONFIG_ESP_COREDUMP_ENABLE=y
CONFIG_ESP_COREDUMP_TO_FLASH=y
CONFIG_ESP_COREDUMP_DATA_FORMAT_ELF=y
CONFIG_ESP_COREDUMP_FLASH_NO_OVERWRITE=n
```
